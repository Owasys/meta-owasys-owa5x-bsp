RDEPENDS:${PN} += " libtss2-tcti-device libtss2-tcti-mssim"
